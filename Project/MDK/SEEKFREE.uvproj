# Keil uVision project SEEKFREE.uvproj, settings and files
target STC8H8K64U (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: SEEKFREE +hex
  c flags: SizeSpeed=1
  c include: ..\..\Libraries\libraries;..\..\Libraries\seekfree_libraries;..\..\Libraries\seekfree_peripheral;..\USER\inc;..\USER\src;..\CODE;..\..\Libraries\seekfree_components
  link misc: REMOVEUNUSED
  group startup
    ../../Libraries/libraries/: common.c common.h board.c board.h STC8Hxx.h
  group seekfree_libraries
    ../../Libraries/seekfree_libraries/: zf_spi.c zf_spi.h zf_iic.c zf_iic.h zf_uart.c zf_uart.h zf_adc.c zf_adc.h zf_tim.c zf_tim.h zf_pwm.c zf_pwm.h zf_exti.c zf_exti.h zf_gpio.c zf_gpio.h zf_eeprom.c zf_eeprom.h zf_delay.c zf_delay.h zf_nvic.c zf_nvic.h zf_mdu16.c zf_mdu16.h zf_fifo.c zf_fifo.h
  group seekfree_peripheral
    ../../Libraries/seekfree_peripheral/: headfile.h SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_ABSOLUTE_ENCODER.c SEEKFREE_ABSOLUTE_ENCODER.h SEEKFREE_BLUETOOTH_CH9141.c SEEKFREE_BLUETOOTH_CH9141.h SEEKFREE_CONFIG.LIB SEEKFREE_CONFIG.h SEEKFREE_DL1B.c SEEKFREE_DL1B.h SEEKFREE_DL1A.c SEEKFREE_DL1A.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_IMU660RA.c SEEKFREE_IMU660RA.h SEEKFREE_IMU963RA.c SEEKFREE_IMU963RA.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h SEEKFREE_WIRELESS_CH573.c SEEKFREE_WIRELESS_CH573.h SEEKFREE_LCD4002_I2C.c SEEKFREE_LCD4002_I2C.h SEEKFREE_SOFT_I2C.c SEEKFREE_SOFT_I2C.h SEEKFREE_INA226.c SEEKFREE_INA226.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h
  group seekfree_components
    ../../Libraries/seekfree_components/: seekfree_assistant.c seekfree_assistant.h seekfree_assistant_inface.c
  group doc
    ../../Libraries/doc/: version.txt
  group user_c
    ../USER/src/: isr.c main.c
  group user_h
    ../USER/inc/: isr.h
